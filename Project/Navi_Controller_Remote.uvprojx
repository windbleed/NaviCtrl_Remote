# Keil uVision project Navi_Controller_Remote.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Navi_Controller_Remote +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\CMSIS\Include;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM0;..\STM32F0xx_StdPeriph_Driver\inc;..\USER;..\CMSIS\Device\ST\STM32F0xx\Include;..\Driver;..\MiddleLayer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030.s
  group STM32F0xx_StdPeriph_Driver
    ../STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_usart.c stm32f0xx_syscfg.c stm32f0xx_misc.c stm32f0xx_adc.c stm32f0xx_tim.c
  group FreeRTOS
    ../FreeRTOS/: list.c queue.c timers.c tasks.c
    ../FreeRTOS/portable/RVDS/ARM_CM0/: port.c
    ../FreeRTOS/portable/MemMang/: heap_2.c
  group USER
    ../USER/: main.c system_stm32f0xx.c stm32f0xx_it.c app.c
    ../MiddleLayer/: TX_Framer.c
  group Drivers
    ../Driver/: LedArray.c Keypad_M.c M24C02.c
  group MiddleLayer
    ../MiddleLayer/: LedCombo.c usart.c CMDParser.c ControllerStatus.c
